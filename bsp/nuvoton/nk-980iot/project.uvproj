# Keil uVision project project.uvproj, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, RT_USING_LIBC
  c misc: --c99 --diag_suppress=1,177,550
  c include: ..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;..\..\..\components\net\sal\include\socket;..\..\..\components\utilities\libadt\avl;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\legacy\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\legacy\usb\usbhost\class;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\drivers\include;packages\nuvoton-arm926-lib-latest\NUC980\UsbHostLib\inc;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\utilities\libadt\ref;..\..\..\components\utilities\libadt\uthash;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\net\sal\impl;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;applications;..\..\..\components\drivers\include;board;..\..\..\components\net\lwip\port;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\utilities\utest;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\include;..\..\..\libcpu\arm\common;..\libraries\nu_packages\SPINAND;..\..\..\components\drivers\include;..\..\..\components\legacy\usb\usbhost\include;..\libraries\nu_packages\AudioCodec;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\legacy\usb\usbhost;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\net\sal\include;..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\libraries\nu_packages\TPC;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\dfs\dfs_v1\filesystems\devfs;packages\nuvoton-arm926-lib-latest\NUC980\Driver\Include;..\..\..\libcpu\arm\arm926;..\..\..\components\legacy\usb\usbdevice;..\libraries\nu_packages\Demo;..\..\..\components\drivers\phy;..\libraries\nuc980\rtt_port;..\..\..\components\drivers\include;..\..\..\components\utilities\libadt\bitmap;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\utilities\libadt\hashmap;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\elmfat
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: mnt.c main.c
  group board
    board/: nu_pin_init.c board_dev.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/clock_time/: clock_time_core.c clock_timer.c clock_timer.c
    ../../../components/drivers/hwcrypto/: hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/mtd/: mtd_nand.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_alarm.c dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_ebi.c drv_spi.c drv_pwm.c drv_can.c drv_i2c.c drv_usbhost.c drv_etimer.c drv_emac.c drv_scuart.c drv_uart.c drv_common.c drv_i2s.c drv_qspi.c drv_wdt.c drv_etimer_capture.c drv_sdh.c drv_softi2c.c drv_crypto.c drv_rtc.c drv_gpio.c drv_adc.c drv_systick.c drv_pdma.c drv_sys.c drv_usbd.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh.c shell.c cmd.c msh_file.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c kstdio.c kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c mmu.c stack.c start_rvds.S trap.c
    ../../../libcpu/arm/common/: div0.c showmem.c
  group Libraries
    packages/nuvoton-arm926-lib-latest/NUC980/Driver/Source/: nu_can.c nu_sdh.c nu_ebi.c nu_wdt.c nu_i2c.c nu_cap.c nu_spi.c nu_emac.c nu_pdma.c nu_sys.c nu_rtc.c nu_uart.c nu_etimer.c nu_scuart.c nu_usbd.c nu_qspi.c nu_wwdt.c nu_i2s.c nu_crypto.c nu_gpio.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c ccap_demo.c wormhole_demo.c usbd_hid_dance_mouse.c ccap_saver.c smp_demo.c hwsem_counter.c slcd_show_tick.c atdev_utils.c
  group nu_pkgs_nau8822
    ../libraries/nu_packages/AudioCodec/: acodec_nau8822.c audio_test.c
  group nu_pkgs_spinand
    ../libraries/nu_packages/SPINAND/: spinand.c drv_spinand.c
  group nuc980_usbhostlib
    packages/nuvoton-arm926-lib-latest/NUC980/UsbHostLib/src/: mem_alloc.c ehci_iso.c usb_core.c ehci.c ohci.c support.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/legacy/usb/usbdevice/class/: cdc_vcom.c mstorage.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: usbhost_core.c driver.c usbhost.c hub.c
    ../../../components/legacy/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: TC_uassert.c utest.c
  group Utilities
    ../../../components/utilities/libadt/avl/: avl.c
