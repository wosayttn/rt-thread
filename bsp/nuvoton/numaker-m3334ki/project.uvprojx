# Keil uVision project project.uvprojx, settings and files
target rtthread-m3331 (6220000::V6.22::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, RT_USING_ARMLIBC, __RTTHREAD__, __STDC_LIMIT_MACROS
  c include: ..\..\..\components\finsh;..\libraries\cortex-m;.;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\phy;packages\nuvoton-series-latest\M3331\Device\Nuvoton\m3331\Include;..\..\..\libcpu\arm\common;board;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\include;..\libraries\nu_packages\Others\NuUtils;board\NuPinConfig;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\include;board\NuClockConfig;..\libraries\nu_packages\Touch\TPC;packages\nuvoton-series-latest\CMSIS\Core\Include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;applications;packages\nuvoton-series-latest\M3331\StdDriver\inc;..\..\..\components\drivers\include;..\..\..\components\net\utest;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: main.c mnt.c pm_test.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/: NTFUN_board_dev.c NUTFT_board_dev.c custom_loader.c nutool_modclkcfg.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    packages/nuvoton-series-latest/M3331/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
    ../libraries/cortex-m/: drv_common.c drv_gpio.c drv_pdma.c drv_sys.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M3331/StdDriver/src/: nu_acmp.c nu_bpwm.c nu_canfd.c nu_clk.c nu_crc.c nu_eadc.c nu_ebi.c nu_ecap.c nu_ellsi.c nu_epwm.c nu_eqei.c nu_fmc.c nu_gpio.c nu_i2c.c nu_i2s.c nu_i3c.c nu_llsi.c nu_pdma.c nu_qspi.c nu_rtc.c nu_sdh.c nu_spi.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_uart.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group numicro_common
    ../libraries/nu_packages/Others/NuUtils/: nu_miscutil.c
