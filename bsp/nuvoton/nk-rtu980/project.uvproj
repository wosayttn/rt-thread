# Keil uVision project project.uvproj, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS
  c misc: --c99
  c include: ..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\libc\compilers\common\extension;..\..\..\components\net\lwip\port;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\components\legacy\usb\usbhost\class;..\..\..\components\legacy\include;..\..\..\libcpu\arm\arm926;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\drivers\include;.;..\..\..\components\drivers\include;..\..\..\components\fal\inc;..\libraries\nu_packages\Demo;..\..\..\components\drivers\hwcrypto;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\nu_packages\TPC;packages\nuvoton-arm926-lib-latest\NUC980\UsbHostLib\inc;..\..\..\components\net\sal\include;..\..\..\components\libc\posix\ipc;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\drivers\include;applications;..\..\..\components\net\netdev\include;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\nuc980\rtt_port;..\..\..\components\drivers\include;..\..\..\components\utilities\libadt\uthash;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\net\sal\include\socket;..\..\..\include;..\..\..\components\finsh;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\legacy\usb\usbhost;..\..\..\components\legacy\usb\usbhost\include;..\..\..\components\utilities\libadt\ref;..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;packages\nuvoton-arm926-lib-latest\NUC980\Driver\Include;..\..\..\components\utilities\libadt\hashmap;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\utilities\libadt\avl;..\..\..\components\drivers\phy;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\spi;..\..\..\components\libc\posix\io\epoll;..\..\..\components\legacy\usb\usbdevice;..\..\..\components\utilities\libadt\bitmap;..\..\..\components\net\sal\impl;..\..\..\components\libc\compilers\common\include;..\..\..\components\utilities\utest;..\..\..\components\dfs\dfs_v1\filesystems\elmfat
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/: nu_pin_init.c board_dev.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/clock_time/: clock_time_core.c clock_timer.c clock_timer.c
    ../../../components/drivers/hwcrypto/: hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c dev_soft_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_sdh.c drv_etimer_capture.c drv_rtc.c drv_usbhost.c drv_pdma.c drv_uart.c drv_common.c drv_sys.c drv_softi2c.c drv_adc.c drv_pwm.c drv_emac.c drv_scuart.c drv_usbd.c drv_spi.c drv_wdt.c drv_ebi.c drv_crypto.c drv_qspi.c drv_can.c drv_gpio.c drv_systick.c drv_etimer.c drv_i2s.c drv_i2c.c
  group Fal
    ../../../components/fal/src/: fal_rtt.c fal_partition.c fal_flash.c fal.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_file.c cmd.c msh.c shell.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c rt_vsscanf.c kstring.c kerrno.c kstdio.c
  group libcpu
    ../../../libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c mmu.c stack.c start_rvds.S trap.c
    ../../../libcpu/arm/common/: div0.c showmem.c
  group Libraries
    packages/nuvoton-arm926-lib-latest/NUC980/Driver/Source/: nu_qspi.c nu_pdma.c nu_emac.c nu_uart.c nu_sys.c nu_wwdt.c nu_can.c nu_i2s.c nu_etimer.c nu_scuart.c nu_cap.c nu_crypto.c nu_i2c.c nu_spi.c nu_rtc.c nu_ebi.c nu_gpio.c nu_usbd.c nu_sdh.c nu_wdt.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: ccap_demo.c usbd_hid_dance_mouse.c wormhole_demo.c hwsem_counter.c ccap_saver.c smp_demo.c usbd_cdc_vcom_echo.c slcd_show_tick.c atdev_utils.c
  group nuc980_usbhostlib
    packages/nuvoton-arm926-lib-latest/NUC980/UsbHostLib/src/: ehci_iso.c mem_alloc.c support.c ehci.c ohci.c usb_core.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/class/: cdc_vcom.c mstorage.c
    ../../../components/legacy/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/class/: udisk.c mass.c
    ../../../components/legacy/usb/usbhost/core/: usbhost_core.c hub.c driver.c usbhost.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: utest.c TC_uassert.c
  group Utilities
    ../../../components/utilities/libadt/avl/: avl.c
