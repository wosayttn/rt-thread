# Keil uVision project project.uvprojx, settings and files
target rtthread-m2354 (6240000::V6.24::ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: RT_USING_ARMLIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_LIBC
  c include: ..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m23;..\libraries\cortex-m;..\..\..\components\finsh;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;packages\nuvoton-series-latest\M2354\Device\Nuvoton\M2354\Include;..\..\..\include;..\..\..\components\net\utest;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\ipc;..\libraries\nu_packages\Touch\TPC;applications;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;board\NuPinConfig;board\NuClockConfig;board;..\..\..\components\drivers\include;packages\nuvoton-series-latest\CMSIS\Core\Include;..\..\..\components\drivers\include;packages\nuvoton-series-latest\M2354\StdDriver\inc;..\libraries\nu_packages\Others\NuUtils;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;.
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/NuClockConfig/: nutool_modclkcfg.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    packages/nuvoton-series-latest/M2354/Device/Nuvoton/M2354/Source/: startup_M2354.c system_M2354.c
    ../libraries/cortex-m/: drv_common.c drv_gpio.c drv_pdma.c drv_sys.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M2354/StdDriver/src/: nu_acmp.c nu_bpwm.c nu_can.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_dpm.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_ewdt.c nu_ewwdt.c nu_fmc.c nu_fvc.c nu_gpio.c nu_i2c.c nu_i2s.c nu_keystore.c nu_lcd.c nu_pdma.c nu_qei.c nu_qspi.c nu_rng.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_sys.c nu_tamper.c nu_timer.c nu_timer_pwm.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group numicro_common
    ../libraries/nu_packages/Others/NuUtils/: nu_miscutil.c
