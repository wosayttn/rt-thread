# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, RT_USING_ARMLIBC
  c misc: --c99
  c include: ..\..\..\components\drivers\include;..\..\..\components\legacy\usb\usbhost;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\net\sal\include\dfs_net;..\libraries\nu_packages\Demo;..\..\..\components\utilities\libadt\uthash;..\..\..\components\net\netdev\include;..\..\..\components\legacy\usb\usbhost\include;..\..\..\components\drivers\audio;..\..\..\components\utilities\libadt\hashmap;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\libc\posix\io\epoll;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\components\drivers\include;.;..\..\..\libcpu\arm\arm926;..\..\..\components\libc\posix\ipc;..\..\..\components\dfs\dfs_v1\include;applications;..\..\..\components\net\lwip\lwip-2.1.2\src\include;packages\nuvoton-arm926-lib-latest\NUC980\UsbHostLib\inc;..\..\..\components\legacy\usb\usbdevice;..\..\..\components\net\sal\impl;..\..\..\components\legacy\usb\usbhost\class;..\..\..\components\drivers\include;..\libraries\nu_packages\SPINAND;..\libraries\nu_packages\TPC;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\components\utilities\libadt\bitmap;..\..\..\components\drivers\include;..\..\..\components\legacy\include;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension;..\..\..\components\net\lwip\port;..\libraries\nuc980\rtt_port;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\hwcrypto;..\..\..\components\utilities\libadt\avl;..\..\..\components\libc\compilers\common\extension\fcntl\octal;board;..\..\..\include;packages\nuvoton-arm926-lib-latest\NUC980\Driver\Include;..\..\..\components\drivers\include;..\..\..\components\utilities\utest;..\..\..\components\utilities\libadt\ref;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\net\sal\include;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\libraries\nu_packages\AudioCodec;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;..\..\..\components\drivers\include
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: mnt.c main.c
  group board
    board/: nu_pin_init.c board_dev.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/clock_time/: clock_time_core.c clock_timer.c clock_timer.c
    ../../../components/drivers/hwcrypto/: hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/mtd/: mtd_nand.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_alarm.c dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_usbd.c drv_adc.c drv_can.c drv_uart.c drv_etimer.c drv_i2s.c drv_qspi.c drv_systick.c drv_usbhost.c drv_common.c drv_gpio.c drv_sdh.c drv_softi2c.c drv_pwm.c drv_pdma.c drv_etimer_capture.c drv_crypto.c drv_emac.c drv_wdt.c drv_sys.c drv_i2c.c drv_spi.c drv_ebi.c drv_scuart.c drv_rtc.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_file.c cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c kstring.c kerrno.c rt_vsscanf.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c mmu.c stack.c start_rvds.S trap.c
    ../../../libcpu/arm/common/: div0.c showmem.c
  group Libraries
    packages/nuvoton-arm926-lib-latest/NUC980/Driver/Source/: nu_emac.c nu_rtc.c nu_wwdt.c nu_cap.c nu_crypto.c nu_scuart.c nu_wdt.c nu_i2c.c nu_uart.c nu_ebi.c nu_qspi.c nu_can.c nu_gpio.c nu_usbd.c nu_sdh.c nu_etimer.c nu_pdma.c nu_spi.c nu_i2s.c nu_sys.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_hid_dance_mouse.c wormhole_demo.c hwsem_counter.c slcd_show_tick.c usbd_cdc_vcom_echo.c ccap_saver.c smp_demo.c atdev_utils.c ccap_demo.c
  group nu_pkgs_nau8822
    ../libraries/nu_packages/AudioCodec/: acodec_nau8822.c audio_test.c
  group nu_pkgs_spinand
    ../libraries/nu_packages/SPINAND/: spinand.c drv_spinand.c
  group nuc980_usbhostlib
    packages/nuvoton-arm926-lib-latest/NUC980/UsbHostLib/src/: ehci_iso.c usb_core.c support.c mem_alloc.c ohci.c ehci.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/legacy/usb/usbdevice/class/: cdc_vcom.c mstorage.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: driver.c usbhost_core.c usbhost.c hub.c
    ../../../components/legacy/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: utest.c TC_uassert.c
  group Utilities
    ../../../components/utilities/libadt/avl/: avl.c
