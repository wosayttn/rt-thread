# Keil uVision project project.uvprojx, settings and files
target rtthread-m5531 (6180000::V6.18::ARMCLANG)
  device: M5531H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.0
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c include: ..\..\..\components\drivers\include;..\..\..\components\drivers\include;applications;..\..\..\components\libc\posix\io\eventfd;UTEST;packages\nuvoton-series-latest\CMSIS\Core\Include;..\..\..\libcpu\arm\common;..\..\..\components\finsh;..\libraries\nu_packages\Others\NuUtils;..\..\..\components\libc\posix\ipc;..\libraries\cortex-m;packages\nuvoton-series-latest\M5531\StdDriver\inc\gdma;packages\nuvoton-series-latest\M5531\StdDriver\inc;board;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\libraries\nu_packages\Touch\TPC;packages\nuvoton-series-latest\M5531\StdDriver;..\..\..\components\utilities\utest;packages\nuvoton-series-latest\M5531\Device\Nuvoton\M5531\Include;packages\nuvoton-series-latest\M5531\StdDriver\inc\scu;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\include;packages\nuvoton-series-latest\M5531\StdDriver\src\scu;..\..\..\components\drivers\include;..\..\..\components\net\utest;..\..\..\components\libc\posix\io\epoll;packages\nuvoton-series-latest\M5531\StdDriver\src\gdma;..\..\..\components\libc\posix\io\poll;..\..\..\libcpu\arm\cortex-m85;.;packages\nuvoton-series-latest\M5531\StdDriver\src;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension\fcntl\octal;board\NuPinConfig
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\linking_scripts\link.scatter
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    packages/nuvoton-series-latest/M5531/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
    ../libraries/cortex-m/: drv_common.c drv_gpio.c drv_pdma.c drv_sys.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M5531/StdDriver/src/gdma/: dma350_address_remap_template.c dma350_ch_drv.c dma350_drv.c dma350_lib.c
    packages/nuvoton-series-latest/M5531/StdDriver/src/: nu_acmp.c nu_awf.c nu_bpwm.c nu_canfd.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_dmic.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_eqei.c nu_fmc.c nu_gpio.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_i3c.c nu_kdf.c nu_ks.c nu_lpadc.c nu_lpgpio.c nu_lpi2c.c nu_lppdma.c nu_lpspi.c nu_lptmr.c nu_lptmr_pwm.c nu_lpuart.c nu_otfc.c nu_pdma.c nu_pmc.c nu_qspi.c nu_rng.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_spim_hyper.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_ttmr.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
    packages/nuvoton-series-latest/M5531/StdDriver/src/scu/: nu_dpm.c nu_fvc.c nu_mpc_sie_drv.c
  group numicro_common
    ../libraries/nu_packages/Others/NuUtils/: nu_miscutil.c
  group UTEST
    UTEST/: utest_bpwm.c utest_canfd.c utest_crypto.c utest_eadc.c utest_fmc.c utest_hwtimer.c utest_pdma.c utest_rtc.c utest_wdt.c
  group UTest
    ../../../components/utilities/utest/: utest.c
