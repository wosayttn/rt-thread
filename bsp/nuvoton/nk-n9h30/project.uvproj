# Keil uVision project project.uvproj, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c misc: --c99 --diag_suppress=1,177,550
  c include: ..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\nuvoton-arm926-lib-latest\N9H30\UsbHostLib\inc;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\legacy\usb\usbdevice;..\..\..\components\utilities\libadt\hashmap;..\..\..\components\drivers\smp_call;..\..\..\libcpu\arm\common;packages\nuvoton-arm926-lib-latest\N9H30\Driver\Include;.;..\libraries\nu_packages\ADC_TOUCH;..\..\..\components\drivers\audio;..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;board;..\..\..\components\drivers\touch;..\..\..\components\utilities\utest;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;applications;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\net\sal\include\dfs_net;..\libraries\nu_packages\TPC;..\libraries\nu_packages\AudioCodec;..\..\..\components\utilities\libadt\avl;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\components\legacy\usb\usbhost;..\..\..\components\net\sal\impl;..\libraries\n9h30\rtt_port;..\..\..\components\utilities\libadt\uthash;..\..\..\components\drivers\spi;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\drivers\include;..\..\..\components\fal\inc;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\utilities\libadt\ref;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;..\..\..\components\legacy\usb\usbhost\class;..\..\..\components\drivers\phy;..\..\..\libcpu\arm\arm926;..\..\..\components\net\lwip\port;..\..\..\components\drivers\include;..\..\..\components\net\sal\include;..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\components\legacy\include;..\..\..\components\net\sal\include\socket;..\..\..\components\drivers\include;..\..\..\components\utilities\libadt\bitmap;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\legacy\usb\usbhost\include;..\..\..\components\drivers\include;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\elmfat
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/: nu_pin_init.c board_dev.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/clock_time/: clock_timer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c rt_inputcapture.c
    ../../../components/drivers/mtd/: mtd_nand.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_alarm.c dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/touch/: dev_touch.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/n9h30/rtt_port/: drv_i2c.c drv_common.c drv_usbd.c drv_sdh.c drv_systick.c drv_usbhost.c drv_i2s.c drv_jpegcodec.c drv_crypto.c drv_gpio.c drv_sys.c drv_vpost.c drv_adc.c drv_etimer_capture.c drv_etimer.c drv_scuart.c drv_emac.c drv_pwm.c drv_wdt.c drv_timer.c drv_ge2d.c drv_can.c drv_uart.c drv_rtc.c drv_softi2c.c drv_qspi.c
  group Fal
    ../../../components/fal/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh_file.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c kstdio.c rt_vsnprintf_tiny.c kstring.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c mmu.c stack.c start_rvds.S trap.c
    ../../../libcpu/arm/common/: div0.c showmem.c
  group Libraries
    packages/nuvoton-arm926-lib-latest/N9H30/Driver/Source/: nu_wwdt.c nu_usbd.c nu_spi.c nu_timer.c nu_i2s.c nu_rtc.c nu_wdt.c nu_fmi.c nu_cap.c nu_sys.c nu_sdh.c nu_scuart.c nu_lcd.c nu_uart.c nu_can.c nu_crypto.c nu_emac.c nu_pwm.c nu_etimer.c nu_gpio.c
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group n9h30_usbhostlib
    packages/nuvoton-arm926-lib-latest/N9H30/UsbHostLib/src/: ehci.c ohci.c ehci_iso.c usb_core.c mem_alloc.c support.c
  group nu_pkgs_adc_touch
    ../libraries/nu_packages/ADC_TOUCH/: touch_sw.c adc_touch.c
  group nu_pkgs_nau8822
    ../libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau8822.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/class/: cdc_vcom.c mstorage.c
    ../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: hub.c driver.c usbhost.c usbhost_core.c
    ../../../components/legacy/usb/usbhost/class/: udisk.c mass.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: utest.c TC_uassert.c
  group Utilities
    ../../../components/utilities/libadt/avl/: avl.c
