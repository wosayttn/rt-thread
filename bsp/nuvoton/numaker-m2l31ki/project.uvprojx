# Keil uVision project project.uvprojx, settings and files
target rtthread-m2354 (6240000::V6.24::ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: __RTTHREAD__, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c include: ..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;applications;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\nuvoton-series-latest\M2L31\Device\Nuvoton\M2L31\Include;..\..\..\components\libc\posix\ipc;..\libraries\nu_packages\Others\NuUtils;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;..\..\..\components\finsh;..\..\..\libcpu\arm\cortex-m23;..\..\..\libcpu\arm\common;..\..\..\components\utilities\utest;.;..\..\..\components\drivers\include;..\..\..\include;packages\nuvoton-series-latest\M2L31\StdDriver\inc;..\libraries\nu_packages\Touch\TPC;..\..\..\components\net\utest;packages\nuvoton-series-latest\CMSIS\Core\Include;board;UTEST;..\..\..\components\drivers\include;board\NuPinConfig;..\..\..\components\libc\posix\io\epoll;..\libraries\cortex-m;..\..\..\components\drivers\smp_call;..\..\..\components\libc\compilers\common\extension
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: main.c mnt.c pm_test.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c custom_loader.c nutool_modclkcfg.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    packages/nuvoton-series-latest/M2L31/Device/Nuvoton/M2L31/Source/: startup_M2L31.c system_M2L31.c
    ../libraries/cortex-m/: drv_common.c drv_gpio.c drv_pdma.c drv_sys.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M2L31/StdDriver/src/: nu_acmp.c nu_canfd.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_eqei.c nu_gpio.c nu_i2c.c nu_lpadc.c nu_lpgpio.c nu_lpi2c.c nu_lppdma.c nu_lpspi.c nu_lptmr.c nu_lptmr_pwm.c nu_lpuart.c nu_pdma.c nu_pwm.c nu_qspi.c nu_rmc.c nu_rng.c nu_rtc.c nu_spi.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_tk.c nu_trng.c nu_ttmr.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group numicro_common
    ../libraries/nu_packages/Others/NuUtils/: nu_miscutil.c
  group UTEST
    UTEST/: nu_i2c_slave_echo.c utest_canfd.c utest_clk.c utest_crypto.c utest_dac.c utest_eadc.c utest_epwm.c utest_eqei.c utest_hwtimer.c utest_i2c.c utest_inputcapture.c utest_inputcapture_ecap.c utest_inputcapture_epwm.c utest_lpadc.c utest_lpi2c.c utest_lppdma.c utest_lpspi.c utest_lpuart.c utest_pdma.c utest_rtc.c utest_spi.c utest_template.c utest_tpwm.c utest_uart.c utest_ui2c.c utest_uspi.c utest_uuart.c utest_wdt.c
  group UTest
    ../../../components/utilities/utest/: utest.c
