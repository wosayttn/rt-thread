# Keil uVision project project.uvprojx, settings and files
target rtthread-m460 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=3 v6LangP=6
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC
  c include: ..\..\..\components\net\utest;..\..\..\components\libc\compilers\common\extension\fcntl\octal;.;packages\nuvoton-series-latest\M460\Device\Nuvoton\m460\Include;board;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\smp_call;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\extension;..\libraries\nu_packages\Others\NuUtils;..\..\..\components\libc\posix\ipc;..\..\..\libcpu\arm\common;..\..\..\include;board\NuPinConfig;..\libraries\cortex-m;..\..\..\components\libc\posix\io\epoll;packages\nuvoton-series-latest\CMSIS\Core\Include;applications;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\libraries\nu_packages\Touch\TPC;packages\nuvoton-series-latest\M460\StdDriver\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: main.c mnt.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    packages/nuvoton-series-latest/M460/Device/Nuvoton/m460/Source/: startup_m460.c system_m460.c
    ../libraries/cortex-m/: drv_common.c drv_gpio.c drv_pdma.c drv_sys.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M460/StdDriver/src/: nu_acmp.c nu_bmc.c nu_bpwm.c nu_canfd.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_eqei.c nu_fmc.c nu_gpio.c nu_hbi.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_keystore.c nu_kpi.c nu_pdma.c nu_qspi.c nu_rng.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group numicro_common
    ../libraries/nu_packages/Others/NuUtils/: nu_miscutil.c
