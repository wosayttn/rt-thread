# Keil uVision project template.uvprojx, settings and files
target rtthread-m480 (6240000::V6.24::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\linking_scripts\link.sct
