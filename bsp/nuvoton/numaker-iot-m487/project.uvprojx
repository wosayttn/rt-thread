# Keil uVision project project.uvprojx, settings and files
target rtthread-m480 (6240000::V6.24::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=1
  c define: __RTTHREAD__, RT_USING_ARMLIBC, RT_USING_LIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;..\libraries\nu_packages\Others\NuUtils;..\..\..\components\libc\posix\io\epoll;packages\nuvoton-series-latest\CMSIS\Core\Include;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\libraries\cortex-m;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\net\utest;.;..\..\..\components\drivers\include;board;..\..\..\components\finsh;board\NuClockConfig;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\drivers\include;board\NuPinConfig;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\eventfd;..\libraries\nu_packages\Touch\TPC;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\nuvoton-series-latest\M480\Device\Nuvoton\M480\Include;..\..\..\components\drivers\spi;packages\nuvoton-series-latest\M480\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\linking_scripts\link.sct
  group Applications
    applications/: main.c mnt.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c
  group Drivers
    board/NuClockConfig/: nutool_modclkcfg.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c
    packages/nuvoton-series-latest/M480/Device/Nuvoton/M480/Source/: startup_M480.c system_M480.c
    ../libraries/cortex-m/: drv_common.c drv_gpio.c drv_pdma.c drv_sys.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M480/StdDriver/src/: nu_acmp.c nu_bpwm.c nu_can.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_eadc.c nu_ebi.c nu_ecap.c nu_emac.c nu_epwm.c nu_fmc.c nu_gpio.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_pdma.c nu_qei.c nu_qspi.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group numicro_common
    ../libraries/nu_packages/Others/NuUtils/: nu_miscutil.c
