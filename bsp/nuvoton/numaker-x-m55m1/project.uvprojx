# Keil uVision project project.uvprojx, settings and files
target rtthread-m55m1 (6180000::V6.18::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, RT_USING_ARMLIBC, __RTTHREAD__, __STDC_LIMIT_MACROS
  c include: ..\..\..\components\finsh;..\..\..\components\drivers\usb\cherryusb\core;..\..\..\components\net\utest;..\..\..\components\net\lwip\lwip-2.0.3\src\include\posix;packages\nuvoton-series-latest\M5531\StdDriver\src\gdma;applications;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\usb\cherryusb\class\hub;..\..\..\components\drivers\usb\cherryusb\class\audio;..\..\..\components\utilities\utest;..\..\..\components\drivers\hwcrypto;..\..\..\components\drivers\usb\cherryusb\class\midi;..\..\..\components\drivers\clock_time;..\libraries\nu_packages\Others\CCAP_Sensors;..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\libraries\cortex-m;packages\nuvoton-series-latest\M5531\StdDriver;..\..\..\components\drivers\usb\cherryusb\common;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;packages\nuvoton-series-latest\M5531\StdDriver\src\scu;..\..\..\components\libc\posix\io\epoll;board;..\..\..\components\drivers\usb\cherryusb\class\video;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\net\lwip\port;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\libraries\nu_packages\Others\NuUtils;..\..\..\components\drivers\include;..\..\..\components\drivers\usb\cherryusb\class\cdc;packages\nuvoton-series-latest\M5531\StdDriver\inc;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\libraries\cortex-m\emac\synopsys;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\usb\cherryusb\class\msc;board\NuPinConfig;..\..\..\components\drivers\usb\cherryusb\class\hid;..\..\..\components\drivers\include;..\libraries\cortex-m\cherryusb_port;..\libraries\cortex-m\cherryusb_port\glue;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\usb\cherryusb\osal;packages\nuvoton-series-latest\M5531\Device\Nuvoton\M5531\Include;..\..\..\components\drivers\usb\cherryusb\class\vendor\net;..\..\..\components\drivers\include;..\..\..\components\drivers\usb\cherryusb;..\..\..\components\drivers\usb\cherryusb\class\serial;..\..\..\components\drivers\smp_call;..\..\..\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\usb\cherryusb\class\dfu;..\..\..\components\drivers\include;packages\nuvoton-series-latest\M5531\StdDriver\inc\scu;..\..\..\components\fal\inc;.;..\..\..\libcpu\arm\cortex-m85;..\..\..\components\drivers\include;..\..\..\components\drivers\usb\cherryusb\class\vendor\wifi;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;UTEST;..\..\..\components\net\lwip\lwip-2.0.3\src\include;packages\nuvoton-series-latest\M5531\StdDriver\inc\gdma;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\cortex-m\cherryusb_port\ehci;..\libraries\nu_packages\Touch\TPC;..\..\..\components\drivers\usb\cherryusb\class\wireless;..\..\..\components\drivers\phy;packages\nuvoton-series-latest\M5531\StdDriver\src;..\..\..\components\drivers\usb\cherryusb\class\adb;..\..\..\components\drivers\include;..\..\..\components\utilities\ulog;..\..\..\components\net\netdev\include;packages\nuvoton-series-latest\CMSIS\Core\Include
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\linking_scripts\link.scatter
  group Applications
    applications/: main.c mnt.c
  group CherryUSB-port
    ../libraries/cortex-m/cherryusb_port/: usb_msh_cmd.c
    ../libraries/cortex-m/cherryusb_port/glue/: glue_nuvoton.c usb_glue_m5531.c
    ../libraries/cortex-m/cherryusb_port/nuvoton/: usb_dc_fs.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    ../../../components/drivers/block/partitions/: dfs.c efi.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/clock_time/: clock_boottime.c clock_hrtimer.c clock_time_core.c clock_timer.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c dac.c pulse_encoder.c rt_drv_pwm.c rt_inputcapture.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/cortex-m/: drv_bpwm.c drv_canfd.c drv_ccap.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_eqei.c drv_fmc.c drv_gpio.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdio.c drv_spi.c drv_sys.c drv_timer.c drv_trng.c drv_uart.c drv_uuart.c drv_wdt.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    packages/nuvoton-series-latest/M5531/Device/Nuvoton/M5531/Source/: startup_M5531.c system_M5531.c
    ../libraries/cortex-m/emac/synopsys/: drv_emac.c mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group Fal
    ../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M5531/StdDriver/src/gdma/: dma350_address_remap_template.c dma350_ch_drv.c dma350_drv.c dma350_lib.c
    packages/nuvoton-series-latest/M5531/StdDriver/src/: nu_acmp.c nu_awf.c nu_bpwm.c nu_canfd.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_dmic.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_eqei.c nu_fmc.c nu_gpio.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_i3c.c nu_kdf.c nu_ks.c nu_lpadc.c nu_lpgpio.c nu_lpi2c.c nu_lppdma.c nu_lpspi.c nu_lptmr.c nu_lptmr_pwm.c nu_lpuart.c nu_otfc.c nu_pdma.c nu_pmc.c nu_qspi.c nu_rng.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_spim_hyper.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_ttmr.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
    packages/nuvoton-series-latest/M5531/StdDriver/src/scu/: nu_dpm.c nu_fvc.c nu_mpc_sie_drv.c
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group nu_pkgs_ccap
    ../libraries/nu_packages/Others/CCAP_Sensors/: ccap_sensor.c sensor_adv728x.c sensor_hm1055.c sensor_ov5640.c sensor_xc7082_ov2718.c
  group numicro_common
    ../libraries/nu_packages/Others/NuUtils/: nu_miscutil.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group UsbStack
    ../../../components/drivers/usb/cherryusb/core/: usbd_core.c usbh_core.c
    ../../../components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
    ../../../components/drivers/usb/cherryusb/class/hid/: usbd_hid.c usbh_hid.c
    ../../../components/drivers/usb/cherryusb/demo/: hid_mouse_template.c
    ../../../components/drivers/usb/cherryusb/class/hub/: usbh_hub.c
    ../../../components/drivers/usb/cherryusb/port/ehci/: usb_hc_ehci.c
    ../../../components/drivers/usb/cherryusb/class/msc/: usbh_msc.c
    ../../../components/drivers/usb/cherryusb/platform/rtthread/: usbh_dfs.c usb_msh.c usb_check.c
  group UTEST
    UTEST/: utest_bpwm.c utest_canfd.c utest_crypto.c utest_eadc.c utest_fmc.c utest_hwtimer.c utest_lppdma.c utest_pdma.c utest_rtc.c utest_uart.c utest_usbhost.c utest_wdt.c
  group UTest
    ../../../components/utilities/utest/: utest.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
