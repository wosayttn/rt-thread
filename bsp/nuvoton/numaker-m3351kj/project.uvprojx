# Keil uVision project project.uvprojx, settings and files
target rtthread-m3351 (6220000::V6.22::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.7
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x30000000,0x20000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) IROM3(0x0F100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __RTTHREAD__
  c include: UTEST;..\..\..\components\drivers\include;packages\nuvoton-series-latest\M3351\StdDriver;board;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;board\NuPinConfig;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\finsh;..\..\..\components\libc\posix\io\poll;packages\nuvoton-series-latest\M3351\StdDriver\src;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\drivers\include;packages\nuvoton-series-latest\CMSIS\Core\Include;..\libraries\cortex-m;..\..\..\components\libc\posix\ipc;..\..\..\components\utilities\utest;packages\nuvoton-series-latest\M3351\StdDriver\inc;..\libraries\nu_packages\Touch\TPC;applications;..\..\..\components\libc\posix\io\eventfd;..\libraries\nu_packages\Others\NuUtils;board\NuClockConfig;.;..\..\..\include;..\..\..\components\net\utest;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension;packages\nuvoton-series-latest\M3351\Device\Nuvoton\M3351\Include;..\..\..\libcpu\arm\common
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\linking_scripts\link.scf
  group Applications
    applications/: lv_example_entry.c main.c mnt.c pm_test.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/: NUTFT_board_dev.c custom_loader.c nutool_modclkcfg.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    packages/nuvoton-series-latest/M3351/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
    ../libraries/cortex-m/: drv_common.c drv_gpio.c drv_pdma.c drv_sys.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M3351/StdDriver/src/: nu_acmp.c nu_bpwm.c nu_canfd.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_dfmc.c nu_eadc.c nu_ebi.c nu_ecap.c nu_ellsi.c nu_eqei.c nu_fmc.c nu_gpio.c nu_i2c.c nu_i3c.c nu_llsi.c nu_pdma.c nu_pwm.c nu_qspi.c nu_rng.c nu_rtc.c nu_spi.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_uart.c nu_usbd.c nu_usci.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group numicro_common
    ../libraries/nu_packages/Others/NuUtils/: nu_miscutil.c
  group UTEST
    UTEST/: bsp_ui2c_mst.c nu_i2c_slave_echo.c utest_bpwm.c utest_canfd.c utest_clk.c utest_crypto.c utest_dac.c utest_eadc.c utest_eqei.c utest_hwtimer.c utest_i2c.c utest_inputcapture.c utest_inputcapture_bpwm.c utest_inputcapture_ecap.c utest_pdma.c utest_rtc.c utest_spi.c utest_spii2s.c utest_template.c utest_tpwm.c utest_uart.c utest_ui2c.c utest_uspi.c utest_uuart.c utest_wdt.c
  group UTest
    ../../../components/utilities/utest/: utest.c
